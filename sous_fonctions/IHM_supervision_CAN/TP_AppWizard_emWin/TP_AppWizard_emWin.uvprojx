# Keil uVision project TP_AppWizard_emWin.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.16.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: TP_AppWizard_emWin
  BeforeMake: C:\Etudiants\git\Projet_IT2R_S4_D1\sous_fonctions\IHM_supervision_CAN\TP_AppWizard_emWin\AppWizzard\generate_gui_all.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Main + Threads
    ./: main.c GUI_SingleThread.c
  group Overclock for LCD with RAM
    ./: configuration.c
  group Source AppWizard
    AppWizzard/Source/: APPW_MainTask.c
    AppWizzard/Source/Generated/: Resource.c APPWConf.c ID_SCREEN_ACCUEIL.c ID_SCREEN_FEUX.c ID_SCREEN_PORTE.c ID_SCREEN_VITESSE.c ID_SCREEN_SON.c ID_SCREEN_PANNEAU.c
    AppWizzard/Source/CustomCode/: ID_SCREEN_ACCUEIL_Slots.c ID_SCREEN_FEUX_Slots.c ID_SCREEN_PORTE_Slots.c ID_SCREEN_VITESSE_Slots.c ID_SCREEN_SON_Slots.c ID_SCREEN_PANNEAU_Slots.c
  group Resource AppWizard
    AppWizzard/Resource/Image/: DARK_Button_Up_100x30.c DARK_Button_Down_100x30.c UNPRESS_right.c PRESS_right.c UNPRESS_home.c PRESS_home.c UNPRESS_left.c PRESS_left.c DARK_Switch_Thumb_26x26.c soleil.c PHARE.c ANALOG_Button_Up_50px50.c ANALOG_Button_Down_50px50.c Voiture_Dessus.c Cadenas_FERME.c DARK_Progbar_Tile_V_Blue_16x1.c Cadenas_ouvert.c DARK_Progbar_Tile_V_Gray_16x1.c ICONE_BATTERIE.c ICONE_HUILE.c lune.c viseur_nunchuk.c vide.c
    AppWizzard/Resource/Movie/: Cligno_DROIT_60x60.c Cligno_GAUCHE_60x60.c
    AppWizzard/Resource/Font/: Roboto_32_Normal_EXT_AA4.c
    AppWizzard/Resource/Text/: APPW_Language_0.c
  group AppWizard Config
    AppWizzard/: APPW_X_FS.c
software components: CMSIS:CORE 6.2.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Board Support:Drivers:Basic I/O 1.1.1, Board Support:Drivers:SDRAM 1.1.1, Board Support:Drivers:Touch Screen 1.1.1, Board Support:Touchscreen 1.1.1, Board Support:emWin LCD 1.1.1, CMSIS Driver:CAN 1.15.0, Device:STM32Cube Framework:Classic 1.3.0, Device:STM32Cube HAL:CAN 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA2D 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:I2C 1.3.0, Device:STM32Cube HAL:LTDC 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:SDRAM 1.3.0, Device:STM32Cube HAL:UART 1.3.0, Device:Startup 1.2.5, Graphics Display:STM32F746G-Discovery 1.0.2, Graphics:CORE 6.32.3, Graphics:Input Device:Touchscreen 6.32.3
